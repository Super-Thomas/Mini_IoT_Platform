# Keil uVision project NuMaker-IoT-M263A_Thomas_BSP.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: NuMaker-IoT-M263A_Thomas_BSP
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\M261\Include;.\Library\StdDriver\inc;.\ThirdParty\FreeRTOS\Source\include;.\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_V8M;.\Drivers;.\;..\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./: main.c main.h lora.c lora.h wifi.c wifi.h esensor.c esensor.h FreeRTOSConfig.h task_priority.h wifi_packet.c wifi_packet.h lora_packet.c lora_packet.h
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c uart.c i2c.c timer.c spi.c retarget.c
  group Drivers
    ./Drivers/: drivers_esensor.c drivers_esensor.h drivers_lora.c drivers_lora.h drivers_wifi.c drivers_wifi.h
  group FreeRTOS
    ./ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_V8M/: port.c
  group CMSIS
    ./Library/Device/Nuvoton/M261/Source/: system_M261.c
    ./Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
